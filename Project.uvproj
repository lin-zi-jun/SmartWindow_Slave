# Keil uVision project Project.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  AfterMake: fromelf.exe --bin -o OBJ/@p.bin OBJ/@p.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\SOFTWARE\APP;.\SOFTWARE\BSP;.\SOFTWARE\DRIVER;.\SOFTWARE\FWLib\INC;.\SOFTWARE\FWLib\M3;.\SOFTWARE\uCOS-III\uC-CPU;.\SOFTWARE\uCOS-III\uC-LIB;.\SOFTWARE\uCOS-III\uCOS-III;.\SOFTWARE\DRIVER;.\SOFTWARE\SYSTEM;.\SOFTWARE\uCGUI\Config;.\SOFTWARE\uCGUI\GUI\AntiAlias;.\SOFTWARE\uCGUI\GUI\ConvertColor;.\SOFTWARE\uCGUI\GUI\ConvertMono;.\SOFTWARE\uCGUI\GUI\Core;.\SOFTWARE\uCGUI\GUI\Font;.\SOFTWARE\uCGUI\GUI\LCDDriver;.\SOFTWARE\uCGUI\GUI\MemDev;.\SOFTWARE\uCGUI\GUI\MultiLayer;.\SOFTWARE\uCGUI\GUI\Widget;.\SOFTWARE\uCGUI\GUI\WM;.\SOFTWARE\uCGUI\GUIDemo;.\SOFTWARE\uCGUI\LCDDriver;.\SOFTWARE\rl-flashfs;.\SOFTWARE\UI;.\SOFTWARE\FONT
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./SOFTWARE/FWLib/M3/: stm32f10x_it.c
    ./SOFTWARE/APP/: APP.c Main.c UITask.c
  group BSP
    ./SOFTWARE/BSP/: bsp.c
  group FWLib
    ./SOFTWARE/FWLib/Startup/: startup_stm32f10x_hd.s
    ./SOFTWARE/FWLib/M3/: core_cm3.c system_stm32f10x.c
    ./SOFTWARE/FWLib/LIB/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_can.c
  group uCOS-III/CPU
    ./SOFTWARE/uCOS-III/uC-CPU/: cpu_c.c cpu_core.c cpu_a.s
  group uCOS-III/LIB
    ./SOFTWARE/uCOS-III/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uCOS-III/Source
    ./SOFTWARE/uCOS-III/uCOS-III/: os_app_hooks.c os_cfg_app.c os_core.c os_cpu_c.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_cpu_a.s
  group DRIVER
    ./SOFTWARE/DRIVER/: ctrio_driver.C USART.c rtc.c MFRC522.c sram.c timer.c delay.c common_func.c hx711.c can.c ili93xx.c iap.c
  group uCGUI/GUI
    ./SOFTWARE/uCGUI/: GUI_X_uCOS.c
  group uCGUI/Config
    ./SOFTWARE/uCGUI/Config/: GUIConf.h GUITouchConf.h LCDConf.h
  group FONT
    ./SOFTWARE/FONT/: FHZK12GUI.C
  group UI
    ./SOFTWARE/UI/: logo.c ui.c
  group uCGUI/Lib
    ./SOFTWARE/uCGUI/GUI_Lib/: ili93xx.lib
